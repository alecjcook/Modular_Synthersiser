** ICL8038_Power **
*
* NI Multisim to SPICE Netlist Export
* Generated by: ACook2
* Thu, Jan 30, 2014 12:16:46
*

*## Multisim Component LED1 ##*
*!!!BEGIN-INTERACT
*  : Ion           ++++f2    ;
*  0.0      VARIABLE   r1Cur
*
*  : LED_OFF
*     1 11 0 SET_SUBCOMP_PRP
*     0 13 0 SET_SUBCOMP_PRP
*     1 12 0 SET_SUBCOMP_PRP
*     0 14 0 SET_SUBCOMP_PRP
*  ;
*
*  : LED_ON
*     0 11 0 SET_SUBCOMP_PRP
*     1 13 0 SET_SUBCOMP_PRP
*     0 12 0 SET_SUBCOMP_PRP
*     1 14 0 SET_SUBCOMP_PRP
*  ;
*
*  :UPDATE_SETTINGS
*     LED_OFF
*  ;
*
*  :OUT_DATA
*     GET_INSTANCE Vsource ::V V  i  ==>_*r1Cur
*     Ion  *r1Cur  0.00004999  f.-   f.<=   if
*        LED_ON
*     else
*        LED_OFF
*     endif
*  ;
*
*  :BEGIN_PLOT
*     LED_OFF
*  ;
*
* !!!END-INTERACT
*
xLED1 7 0 LED_redLED1
*
.SUBCKT LED_redLED1  K A
D1 1 A  LED_mod
V   K  1  DC 0
.MODEL LED_mod D (
+ IS=1.024e-017 N=2.005e+000 RS=2.342e-003
+ BV=6.100e+001 IBV=6.000e-006
+ EG=1.110e+000 XTI=3.000e+000
+ CJO=3.238e-011, M=3.388e-001 VJ=3.250e-001
+ FC=5.000e-001 KF=0.000e+000 AF=1.000e+000 )
.ENDS

*## Multisim Component R3 ##*
rR3 +12V 7 1200 vresR3
.model vresR3 r(  )

*## Multisim Component C6 ##*
cC6 -12V 0 1e-008

*## Multisim Component C5 ##*
cC5 +12V 0 1e-008

*## Multisim Component C4 ##*
cC4 -12V 0 1e-007

*## Multisim Component C3 ##*
cC3 +12V 0 1e-007

*## Multisim Component C2 ##*
cC2 3 0 0.00047

*## Multisim Component C1 ##*
cC1 1 0 0.00047

*## Multisim Component U2 ##*
xU2 3 0 -12V LM7912CT__VOLTAGE_REGULATOR__1

*## Multisim Component U1 ##*
xU1 1 0 +12V LM7812CT__VOLTAGE_REGULATOR__1

*## Multisim Component R2 ##*
rR2 0 3 10000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 1 0 10000 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 1 3 dc 24 ac 0 0
+           distof1 0 0
+           distof2 0 0

.SUBCKT LM7912CT__VOLTAGE_REGULATOR__1 1 2 3
* NEGATIVE 3 TERMINAL VOLTAGE REGULATOR
* PIN 1 = VOLTAGE INPUT
* PIN 2 = VOLTAGE REF (USUALLY GND)
* PIN 3 = VOLTAGE OUTPUT
* OUTPUT VOLTAGE = V1 - 1.3v
R1 5  3 50
R2 1  4 10000
R3 3  2 10000
V1 4  2 dc -13.3
Q2 1 4 5 CNTL_PNP
Q1 1 5 3 POWER_PNP
*
.MODEL POWER_PNP PNP
+IS=9.22554e-15 BF=7026.13 NF=0.875675 VAF=121.334
+IKF=1 ISE=4.16599e-14 NE=1.16082 BR=0.1
+NR=1.5 VAR=0.840001 IKR=10 ISC=4.16599e-14
+NC=1 RB=1.16529 IRB=0.1 RBM=1.16529
+RE=0.0001 RC=3.25699 XTB=0.1 XTI=1
+EG=1.206 CJE=1.98647e-10 VJE=0.4 MJE=0.85
+TF=1.6698e-09 XTF=1000 VTF=1.23886 ITF=13.7503
+CJC=4.56014e-11 VJC=0.95 MJC=0.463492 XCJC=0.84185
+FC=0.1 CJS=0 VJS=0.75 MJS=0.5
+TR=1e-07 PTF=0 KF=0 AF=1
.MODEL CNTL_PNP PNP
+IS=6.28714e-14 BF=386.157 NF=1.04671 VAF=10
+IKF=0.189462 ISE=1.92795e-13 NE=1.41391 BR=0.1
+NR=1.14919 VAR=1.3773 IKR=0.853995 ISC=1.92795e-13
+NC=2.83982 RB=18.4538 IRB=0.1 RBM=0.1
+RE=0.0561856 RC=1.23424 XTB=0.251412 XTI=1
+EG=1.05 CJE=2.79854e-11 VJE=0.718974 MJE=0.375151
+TF=5.18862e-10 XTF=1.5 VTF=0.999999 ITF=1
+CJC=1.98079e-11 VJC=0.4 MJC=0.393215 XCJC=0.8
+FC=0.649759 CJS=0 VJS=0.75 MJS=0.5
+TR=1.16047e-06 PTF=0 KF=0 AF=1
.ENDS

.SUBCKT LM7812CT__VOLTAGE_REGULATOR__1 1 2 3
* POSITIVE 3 TERMINAL VOLTAGE REGULATOR
* PIN 1 = VOLTAGE INPUT
* PIN 2 = VOLTAGE REF (USUALLY GND)
* PIN 3 = VOLTAGE OUTPUT
* OUTPUT VOLTAGE = V1 - 1.3v
R1 5  3 50
R2 1  4 10000
R3 3  2 10000
V1 4  2 dc 13.3
Q2 1 4 5 CNTL_NPN
Q1 1 5 3 POWER_NPN
*
.MODEL CNTL_NPN NPN(Is=6.734f Xti=3 Eg=1.11 Vaf=74.03 Bf=416.4 Ne=1.259
+               Ise=6.734f Ikf=66.78m Xtb=1.5 Br=.7371 Nc=2 Isc=0 Ikr=0 Rc=1
+               Cjc=3.638p Mjc=.3085 Vjc=.75 Fc=.5 Cje=4.493p Mje=.2593 Vje=.75
+               Tr=239.5n Tf=301.2p Itf=.4 Vtf=4 Xtf=2 Rb=10)
.MODEL POWER_NPN NPN
+IS=3.41639e-13 BF=405.26 NF=1.03507 VAF=120.176
+IKF=10 ISE=8.44498e-12 NE=3.47601 BR=0.1
+NR=1.04536 VAR=1.10398 IKR=2.5029 ISC=5.50017e-13
+NC=3.93748 RB=1.80955 IRB=6.50293 RBM=1.80955
+RE=0.0001 RC=0.13777 XTB=0.1 XTI=1
+EG=1.05 CJE=6.36056e-10 VJE=0.4 MJE=0.479146
+TF=7.91835e-08 XTF=463.212 VTF=62107.5 ITF=1000
+CJC=2.70642e-10 VJC=0.95 MJC=0.406578 XCJC=0.128859
+FC=0.8 CJS=0 VJS=0.75 MJS=0.5
+TR=8.186e-05 PTF=0 KF=0 AF=1
.ENDS
